<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\display.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\interrupt.ewp</path>
    </project>
    <batchBuild />
</workspace>
